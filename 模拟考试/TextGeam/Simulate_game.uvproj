# Keil uVision project Simulate_game.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Simulate_game +hex
  c flags: Optimize=8 SizeSpeed=1
  group Use
    ../历年国赛真题练习/第八届超声波测距机（DAC、EEPROM）/: Display.h ds1302.h Head.h iic.h Key.h Sonic.h
  group Head
    ../历年国赛真题练习/第八届超声波测距机（DAC、EEPROM）/: Display.c ds1302.c iic.c Key.c Main.c Sonic.c
