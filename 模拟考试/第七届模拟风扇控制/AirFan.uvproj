# Keil uVision project AirFan.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AirFan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Use
    ./: Display.c Key.c Main.c onewire.c ds1302.c iic.c
  group Head
    ./: onewire.h ds1302.h iic.h Key.h Head.h Display.h
