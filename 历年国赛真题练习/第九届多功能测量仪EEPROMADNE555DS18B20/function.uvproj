# Keil uVision project function.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: function +hex
  c flags: Optimize=8 SizeSpeed=1
  group Use
    ./: Display.c iic.c Key.c Main.c onewire.c
  group Head
    ./: Display.h Head.h iic.h Key.h onewire.h
