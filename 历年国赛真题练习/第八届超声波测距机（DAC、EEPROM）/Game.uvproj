# Keil uVision project Game.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Game +hex
  c flags: Optimize=8 SizeSpeed=1
  group Use
    ../第九届多功能测量仪EEPROMADNE555DS18B20/: Display.c Display.h Head.h iic.c iic.h Key.c Key.h Main.c onewire.c onewire.h
