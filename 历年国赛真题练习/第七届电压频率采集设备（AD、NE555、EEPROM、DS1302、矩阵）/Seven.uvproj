# Keil uVision project Seven.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Seven +hex
  c flags: Optimize=8 SizeSpeed=1
  group Use
    ./: Display.c ds1302.c iic.c Key.c Main.c
  group Head
    ./: Display.h ds1302.h Head.h iic.h Key.h
